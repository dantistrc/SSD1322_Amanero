# Keil uVision project SSD1322_Amanero.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SSD1322_Amanero +hex
  c flags: Optim=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c misc: -mfloat-abi=soft
  c include: .\cmsis;.\cmsis_boot;.\main;.\GPIO;.\Delay;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;.\SPI_SSD1322\inc;.\DispPort\inc;.\cmsis_boot\startup;.\Encoder;.\ControlPort\inc;./UART_XMOS;./IR_REMOTE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./cmsis_boot/startup/: startup_stm32f10x_md.s
  group main
    ./main/: main.c
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c
  group Delay
    ./Delay/: Delay.c
  group DispPort
    ./DispPort/src/: DispPort.c
  group SPI_SSD1322
    ./SPI_SSD1322/src/: spi_ssd1322.c
  group System
    ./cmsis_boot/: system_stm32f10x.c
  group Encoder
    ./Encoder/: encoder.c
  group ControlPort
    ./ControlPort/src/: ControlPort.c
    ./ControlPort/inc/: ControlPort.h
  group UART_XMOS
    ./UART_XMOS/: UART_XMOS.c
  group ir_remote
    ./IR_REMOTE/: ir_remote.c
software components: CMSIS:CORE 5.6.0
